Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: F:\\BRICSCAD\\Oljeutskillere\\_BIM filer\\SUK-H\\8383785 Odin Oljeutskiller SUK-H NS15.ifc
Time: 2023-03-08T14:52:17
Author: Undefined
Organization: Undefined
Written by: BricsCAD BIM 23.1.08
Made in: BricsCAD BIM 23.1.08
Authorization: Undefined

# IfcSite, Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Site
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
